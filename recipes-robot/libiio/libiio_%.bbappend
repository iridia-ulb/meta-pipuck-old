EXTRA_OECMAKE_append = " -DLOG_LEVEL=Error"
